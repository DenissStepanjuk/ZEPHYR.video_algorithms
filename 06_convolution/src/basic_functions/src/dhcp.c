// Секции линкера Zephyr: макросы вроде __net_mgmt_event_callback_start
// и подобные "секционные" атрибуты. Сетевой стек Zephyr использует
// именованные секции памяти для некоторых внутренних механизмов
// (в частности, для системы событий net_mgmt), поэтому заголовок
// подключается как зависимость net_mgmt.h.
#include <zephyr/linker/sections.h>
        
// Стандартные коды ошибок POSIX (errno) — EINVAL, ENOMEM, EAGAIN и т.д.
// Многие функции сетевого стека Zephyr возвращают отрицательные
// значения этих кодов при ошибке.
#include <errno.h>

// Основной заголовок работы с сетевыми интерфейсами Zephyr:
// struct net_if, net_if_get_default(), net_if_get_by_iface(),
// структура config.ip.ipv4 внутри net_if и т.д. Именно отсюда
// берётся тип struct net_if *iface, который передаётся в handler().
#include <zephyr/net/net_if.h>

// Базовые сетевые определения ядра: константы семейств адресов
// (AF_INET), общие макросы и типы, на которые опирается остальной
// сетевой стек (net_core.h — своего рода "фундамент" net-подсистемы).
#include <zephyr/net/net_core.h>

// API сетевого контекста (net_context) — низкоуровневая абстракция
// поверх сокетов, используемая внутри сетевого стека. Напрямую в этом
// фрагменте не используется, но тянется как транзитивная зависимость
// для полноценной работы с net_if/net_mgmt.
#include <zephyr/net/net_context.h>

// API системы управления сетевыми событиями (Net Management):
// struct net_mgmt_event_callback, net_mgmt_init_event_callback(),
// net_mgmt_add_event_callback(), константа события
// NET_EVENT_IPV4_ADDR_ADD. Это ключевой заголовок для всего механизма
// "подписки на событие получения IP-адреса", который здесь реализован.
#include <zephyr/net/net_mgmt.h>

#include <zephyr/logging/log.h>
LOG_MODULE_REGISTER(DHCP_LOG, LOG_LEVEL_DBG);

// Глобальная структура-колбэк для системы net_mgmt. Она хранит внутри себя: указатель на функцию
// handler (которая будет вызвана при наступлении события), маску событий, на которые оформлена подписка, и служебные поля для
// связывания в внутренний список подписчиков net_mgmt. Объявлена без static, то есть видна и в других единицах трансляции (.c файлах)
// проекта — например, именно на неё ссылается main() в основном файле через extern mgmt_cb.
struct net_mgmt_event_callback mgmt_cb;
    
// Функция-обработчик сетевых событий. Регистрируется через
// net_mgmt_init_event_callback(&mgmt_cb, handler, NET_EVENT_IPV4_ADDR_ADD)
// и net_mgmt_add_event_callback(&mgmt_cb) в main(). После этого
// подсистема net_mgmt будет автоматически вызывать handler() каждый
// раз, когда на любом сетевом интерфейсе происходит событие,
// подпадающее под маску подписки (в данном случае — только
// NET_EVENT_IPV4_ADDR_ADD, "интерфейсу назначен IPv4-адрес").
// Вызывается в контексте системного потока net_mgmt (собственного
// потока-обработчика событий ядра), а не из основного потока main().
// Параметры функции:
    //  - cb         — указатель на ту самую структуру-колбэк
    //                 (здесь это будет указатель на глобальную mgmt_cb),
    //                 через которую при необходимости можно достать
    //                 дополнительный контекст (в этой функции cb не используется вообще).
    //  - mgmt_event — код произошедшего события (битовая маска-идентификатор,
    //                 например NET_EVENT_IPV4_ADDR_ADD). Подсистема net_mgmt
    //                 может вызывать один и тот же handler для НЕСКОЛЬКИХ
    //                 типов событий, если бы подписка была оформлена на
    //                 более широкую маску — поэтому внутри обязательно
    //                 нужно проверять, какое именно событие пришло.
    //  - iface      — указатель на сетевой интерфейс, с которым связано
    //                 событие (например, конкретный Ethernet-контроллер
    //                 платы). Через него мы получаем доступ ко всей IP-конфигурации этого интерфейса.
void handler(struct net_mgmt_event_callback *cb,
            uint64_t mgmt_event,
            struct net_if *iface){
    // Индекс для перебора массива unicast-адресов интерфейса ниже.
    int i = 0;
    
    // Фильтр по типу события: поскольку теоретически handler мог бы быть
    // подписан сразу на несколько типов событий net_mgmt, здесь явно
    // проверяем, что сработавшее событие — именно "добавлен IPv4-адрес".
    // Если это какое-то другое событие (которого в данной подписке быть
    // не должно, но проверка всё равно стоит для безопасности/расширяемости),
    // функция просто выходит, ничего не делая.
    if (mgmt_event != NET_EVENT_IPV4_ADDR_ADD) {
        return;
    }
    
    // У каждого сетевого интерфейса может быть НЕСКОЛЬКО IPv4-адресов
    // одновременно (unicast-адресов) — например, один назначен вручную,
    // другой получен по DHCP. NET_IF_MAX_IPV4_ADDR — константа Zephyr
    // (обычно определяется через Kconfig, по умолчанию небольшое число,
    // например 2 или 3), задающая максимальный размер массива
    // iface->config.ip.ipv4->unicast[]. Цикл перебирает ВСЕ слоты этого
    // массива, чтобы найти тот адрес, который был выдан именно DHCP-сервером
    // (могут быть и пустые/неиспользуемые слоты, и адреса другого типа).
    for (i = 0; i < NET_IF_MAX_IPV4_ADDR; i++) {

        // Локальный текстовый буфер для строкового представления IP-адреса
        // в формате "ддд.ддд.ддд.ддд". NET_IPV4_ADDR_LEN — константа Zephyr,
        // равная максимальной длине такой строки с учётом завершающего
        // нуля (обычно 16 байт: "255.255.255.255\0"). Буфер объявлен
        // внутри тела цикла — новый на каждой итерации (безопасно, т.к.
        // используется только "локально и сразу", без сохранения указателя на него после итерации).
        char buf[NET_IPV4_ADDR_LEN];
    
        // Проверяем тип текущего unicast-адреса в массиве. Поле addr_type
        // показывает, откуда взялся адрес: NET_ADDR_MANUAL (задан вручную),
        // NET_ADDR_AUTOCONF, NET_ADDR_DHCP (получен от DHCP-сервера) и т.д.
        // Если очередной слот массива не является DHCP-адресом (это может
        // быть пустой/неинициализированный слот или адрес другого типа) —
        // continue пропускает его и переходит к следующей итерации,
        // не выводя для него никакой информации.
        if (iface->config.ip.ipv4->unicast[i].ipv4.addr_type != NET_ADDR_DHCP) {
            continue;
        }
    
        // Если дошли сюда — найден слот с адресом от DHCP-сервера. Выводим в лог сам IP-адрес. 
        // net_addr_ntop() — функция преобразования бинарного сетевого
        // адреса в текстовую строку (аналог стандартной POSIX-функции inet_ntop, "ntop" = Network TO Presentation). 
        // Аргументы:
        //   AF_INET                          — семейство адресов IPv4;
        //   &...address.in_addr               — указатель на бинарный
        //                                        4-байтовый IPv4-адрес
        //                                        внутри структуры unicast[i];
        //   buf, sizeof(buf)                  — куда и сколько байт максимум
        //                                        писать результирующую строку.
        // Функция возвращает указатель на buf (или NULL при ошибке),
        // который сразу передаётся как аргумент форматной строки в LOG_INF —
        // то есть преобразование и логирование происходят "в одну строку".
        LOG_INF("Your address: %s",
                net_addr_ntop(AF_INET,
                &iface->config.ip.ipv4->unicast[i].ipv4.address.in_addr, buf, sizeof(buf)));
            
        // Выводим в лог время аренды (lease time) DHCP-адреса в секундах —
        // то есть сколько секунд действителен полученный адрес, прежде чем
        // клиенту нужно будет продлевать аренду (DHCP RENEW) или получать
        // новый адрес заново. Поле lease_time хранится не в самом
        // unicast-адресе, а в отдельной структуре config.dhcpv4,
        // связанной с интерфейсом в целом (а не с конкретным адресом),
        // поэтому обращение идёт напрямую через iface->config.dhcpv4, без индекса i.
        LOG_INF("Lease time: %u seconds", iface->config.dhcpv4.lease_time);

        // Аналогично адресу — выводим маску подсети (netmask), тоже
        // конвертируя её из бинарного вида в текстовый через net_addr_ntop().
        // Маска хранится непосредственно в структуре unicast[i] (в отличие
        // от lease_time), т.к. в IPv4 маска логически привязана именно
        // к конкретному адресу/подсети, а не к интерфейсу в целом.
        LOG_INF("Subnet: %s", net_addr_ntop(AF_INET,
                &iface->config.ip.ipv4->unicast[i].netmask, buf, sizeof(buf)));

        // Выводим адрес шлюза по умолчанию (gateway/router), который
        // DHCP-сервер сообщил вместе с адресом. Обратите внимание: поле
        // gw хранится в config.ip.ipv4 (общее для интерфейса, а не для
        // конкретного unicast-слота i) — то есть шлюз один на интерфейс,
        // а не на каждый отдельный IP-адрес.
        LOG_INF("Router: %s", net_addr_ntop(AF_INET,
                &iface->config.ip.ipv4->gw, buf, sizeof(buf)));
    }
}